# IAR project dieu_khien_dong_co_PID.ewp, settings and files
configuration dieu_khien_dong_co_PID (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401CC ST STM32F401CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xC
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Core\Cpp\Flow\Data_Config\Inc; ..\Core\Cpp\Flow\Input\Inc; ..\Core\Cpp\Flow\Main\Inc; C:\Users\taduc\Downloads\do_an_tot_nghiep-master\do_an_tot_nghiep-master\Core\Cpp\Flow\Output\Inc; ..\Core\Cpp\Library\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: dieu_khien_dong_co_PID.hex
  ILINK.IlinkOutputFile: dieu_khien_dong_co_PID.out
  ILINK.IlinkIcfFile: stm32f401xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/Cpp
    ../Core/Cpp/Flow/Data_Config/Src/: data.cpp
    ../Core/Cpp/Flow/Input/Src/: input.cpp
    ../Core/Cpp/Flow/Main/Src/: ledmain.cpp main_cpp.cpp
    ../Core/Cpp/Flow/Output/Src/: odometry.cpp
  group Application/User/Cpp/Library
    ../Core/Cpp/Library/Src/: i2c_software.cpp MotorControl.cpp MotorControlPID.cpp pid.cpp QMC5883LCompass.cpp uartDMA.cpp
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
