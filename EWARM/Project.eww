<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\dieu_khien_dong_co_PID.ewp</path>
  </project>
  <batchBuild />
</workspace>
