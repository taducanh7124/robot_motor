# IAR project ROBOT_F411.ewp, settings and files
configuration ROBOT_F411 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Core\Cpp\FunctionCpp\Inc; ..\Core\Cpp\LibraryCpp\Inc; ..\Core\Cpp\MainCpp\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: ROBOT_F411.hex
  ILINK.IlinkOutputFile: ROBOT_F411.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/Core/Cpp/FunctionCpp/Inc
    ../Core/Cpp/FunctionCpp/Inc/: const.hpp data.hpp HCSR04.hpp input_output.hpp MotorControl.hpp MPU6050.hpp UART_DMA.hpp
  group Application/User/Core/Cpp/FunctionCpp/Src
    ../Core/Cpp/FunctionCpp/Src/: const.cpp data.cpp HCSR04.cpp input_output.cpp MotorControl.cpp MPU6050.cpp UART_DMA.cpp
  group Application/User/Core/Cpp/LibraryCpp/Inc
    ../Core/Cpp/LibraryCpp/Inc/: pin_config.hpp
  group Application/User/Core/Cpp/MainCpp/Inc
    ../Core/Cpp/MainCpp/Inc/: led_main.hpp main_cpp.hpp
  group Application/User/Core/Cpp/MainCpp/Src
    ../Core/Cpp/MainCpp/Src/: led_main.cpp main_cpp.cpp
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
